# Keil uVision project 1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: 1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH
  c include: ..\1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: startup_stm32f10x_cl.s main.c periph.c filmobus3.h filmobus3.c
